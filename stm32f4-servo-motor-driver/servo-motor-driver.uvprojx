# Keil uVision project servo-motor-driver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: servo-motor-driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, HSE_VALUE=8000000
  c include: ..\stm32f4-servo-motor-driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main_Group
    ./: main.c
  group ma_libs
    ../ma_libs/: ma_delay.c ma_delay.h ma_gpio.c ma_gpio.h ma_rcc.c ma_rcc.h ma_servo.c ma_servo.h ma_tim.c ma_tim.h
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0
